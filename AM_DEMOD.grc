options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: AM_DEMOD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_rate
  id: variable
  parameters:
    value: '900001'
  states: {}
- name: frag_rate
  id: variable
  parameters:
    value: file_rate/samp_rate
  states: {}
- name: freq
  id: variable
  parameters:
    value: '125400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '0.0654'
    min_freq: '-0.0654'
    w: '0.05'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '6e+3'
    low_cutoff_freq: '500'
    samp_rate: '48e+3'
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cxn4689/Desktop/SDR/GNU Radio GK2A/SDRSharp_20230121_125103Z_125400000Hz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6e+3'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2e+3'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: frag_rate
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    dc_offset_mode0: '1'
    freq0: '125400000'
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '100000'
    fc: freq
    fftsize: '1024'
    type: complex
    ymin: '-40'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '1'
    freq0: '125400000'
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', mmse_resampler_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']
- [rtlsdr_source_0, '0', mmse_resampler_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
