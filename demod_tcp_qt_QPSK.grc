options:
  parameters:
    author: Lucas Teske
    description: https://github.com/racerxdl/open-satellite-project
    generate_options: qt_gui
    id: demod_tcp_qt
    output_language: python
    title: LRIT Demodulator
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Clock Alpha
    min_len: '150'
    start: '1e-3'
    step: '1e-5'
    stop: '10e-3'
    value: '3.7e-3'
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: '900001'
  states: {}
- name: lnagain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: LNA Gain
    min_len: '150'
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '15'
  states: {}
- name: low_pass_bandwidth
  id: variable
  parameters:
    value: '130000'
  states: {}
- name: mixgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Mixer Gain
    min_len: '150'
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '15'
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: PLL Alpha
    min_len: '150'
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '0.00199'
  states: {}
- name: polyphase_rate
  id: variable
  parameters:
    value: (samp_rate*1.0)/(file_rate*1.0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '288000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: vgagain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: VGA Gain
    min_len: '150'
    start: '0'
    step: '1'
    stop: '15'
    value: '15'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '4000'
    rate: '100e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blks2_tcp_sink_0
  id: blks2_tcp_sink
  parameters:
    addr: 127.0.0.1
    port: '5000'
    server: 'False'
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cxn4689/Desktop/SDR/GNU Radio GK2A/grc72k.s
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: '64'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_U8
    file: /home/cxn4689/Desktop/SDR/GNU Radio GK2A/72k.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: symbol_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/cxn4689/Desktop/SDR/GNU Radio GK2A/SDRSharp_20220829_224006Z_137100000Hz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: symbol_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 300e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '10'
    gain: '1'
    samp_rate: samp_rate*10
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate * 2
    decim: '3'
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: low_pass_bandwidth
    decim: '1'
    gain: '1'
    samp_rate: file_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate * 2
    decim: '2'
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '3.125'
    type: complex
  states: {state: disabled}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '5000'
    type: byte
    vlen: '64'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: Airspy Mini
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: RTLSDR
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: SNR Meter
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: GQRX Record
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Airspy R2
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: file='D:\SDR\SDRSharp\SDRSharp\bin\SDRSharp_20220925_112952Z_1692140000Hz_IQ.wav',rate=2560000
    bb_gain0: mixgain
    dc_offset_mode0: '1'
    freq0: center_freq
    gain0: lnagain
    gain_mode0: 'True'
    if_gain0: vgagain
    iq_balance_mode0: '1'
    sample_rate: samp_rate*10
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: airspy=0
    bb_gain0: mixgain
    dc_offset_mode0: '1'
    freq0: center_freq
    gain0: lnagain
    gain_mode0: 'False'
    if_gain0: vgagain
    iq_balance_mode0: '1'
    sample_rate: 6e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '40'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '40'
    iq_balance_mode0: '1'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: polyphase_rate
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    axislabels: 'False'
    color1: '"dark green"'
    grid: 'True'
    gui_hint: 0,1,2,1
    legend: 'False'
    name: Output Constellation
    size: '1024'
    type: complex
    update_time: '0.01'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    axislabels: 'False'
    bw: '288000'
    color1: '"dark red"'
    fc: center_freq
    fftsize: '8192'
    grid: 'True'
    gui_hint: 0,0,2,1
    legend: 'False'
    name: Input Signal
    showports: 'True'
    type: complex
    update_time: '0.05'
    ymax: '-35'
    ymin: '-50'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '0.3'
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: 0,2,7,1
    label1: ' '
    max: '10'
    min: '0'
    name: SNR
    type: float
    unit1: dB
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '3'
    fc: center_freq
    fftsize: '8192'
    gui_hint: 2,0,5,1
    int_max: '-40'
    int_min: '-50'
    legend: 'False'
    showports: 'True'
    type: complex
    update_time: '0.05'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.6'
    decim: '1'
    gain: '1'
    ntaps: '63'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', high_pass_filter_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_1, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_char_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_char_1, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_stream_to_vector_0, '0', blks2_tcp_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', network_tcp_sink_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_float_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [high_pass_filter_0, '0', blocks_rms_xx_0_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0_0_0, '0', pfb_arb_resampler_xxx_0, '0']
- [mmse_resampler_xx_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0_0, '0', low_pass_filter_0_0, '0']
- [osmosdr_source_0_1, '0', low_pass_filter_0_1, '0']
- [pfb_arb_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_rms_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
